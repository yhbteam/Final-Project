# Keil uVision project project1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\System;.\Hardware;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group System
    ./System/: Delay.h Delay.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h led.c led.h USART.c USART.h DHT11.c DHT11.h fm.c fm.h servo.h servo.c buzzer.c buzzer.h infrared.c infrared.h Motor.h Motor.c
  group FreeRTOS\inc
    ./FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS\src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\port
    ./FreeRTOS/port/: heap_4.c port.c portmacro.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
